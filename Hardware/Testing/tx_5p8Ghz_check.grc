options:
  parameters:
    generate_options: qt_gui
    id: edr_check
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 5.8e9
  states: {}
- name: receiver_gain
  id: variable_qtgui_range
  parameters:
    start: '20'
    step: '5'
    stop: '60'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.25'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 4e6
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: 1e4
    center_freq: center_freq
    dev_args: buffers=64,buflen=16384,bladerf=0,dc_offset_mode=manual
    gain: receiver_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_bladerf_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_bladerf_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
